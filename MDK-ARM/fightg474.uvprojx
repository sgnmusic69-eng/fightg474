# Keil uVision project fightg474.uvprojx, settings and files
target fightg474 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: fightg474 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../enigmaa/MyAPL;../../enigmaa/MyBLL;../../enigmaa/MyFML;../../enigmaa/MyHDL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c dac.c dma.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group MyHDL
    ../../enigmaa/MyHDL/: My_SPI.c My_SPI.h
  group MyFML
    ../../enigmaa/MyFML/: ad9833.c adc_fml.c fft_fml.c ad9833.h adc_fml.h fft_fml.h
  group MyBLL
    ../../enigmaa/MyBLL/: adc_bll.c dds_bll.c fft_bll.c adc_bll.h dds_bll.h fft_bll.h
  group MyAPL
    ../../enigmaa/MyAPL/: adc_apl.c dds_apl.c fft_apl.c adc_apl.h dds_apl.h fft_apl.h
  group sthvaluable
    ../../nuedc_2023H/src/: AD9833.c flexible_button.c freqDiv.c gui.c judge.c key_event.c oled.c oledfont.c
    ../../nuedc_2023H/inc/: AD9833.h flexible_button.h freqDiv.h gui.h judge.h key_event.h oled.h oledfont.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
